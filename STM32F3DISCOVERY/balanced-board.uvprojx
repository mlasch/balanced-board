# Keil uVision project balanced-board.uvprojx, settings and files
target f3 discovery board (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: imu_sensors
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F303xC,USE_HAL_DRIVER,HSI_VALUE=8000000
  c include: ..\STM32Cube_FW_F3_V1.5.0\Drivers\STM32F3xx_HAL_Driver\Inc;..\STM32Cube_FW_F3_V1.5.0\Drivers\CMSIS\Include;..\STM32Cube_FW_F3_V1.5.0\Drivers\CMSIS\Device\ST\STM32F3xx\Include;.\user_files\inc;.\drivers\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group user_files
    ./user_files/src/: main.c system_stm32f3xx.c startup_stm32f303xc.s stm32f3xx_it.c timer.c stm32f3xx_hal_msp.c threads.c fputc_debug.c
  group stm32_hal
    ../STM32Cube_FW_F3_V1.5.0/Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc.c stm32f3xx_hal_cortex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_dma.c stm32f3xx_hal_spi.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c
  group drivers
    ./drivers/src/: lsm303dlhc.c l3gd20.c uart_debug.c
software components: CMSIS:RTOS:Keil RTX 4.81.0
